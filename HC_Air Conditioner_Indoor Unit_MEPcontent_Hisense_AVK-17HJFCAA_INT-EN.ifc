Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-10-11T11:47:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 11 11:47:04 2018 * Host: B3ROBRAWR2780 * Database: C:\Users\RVI\AppData\Local\Temp\{EBB7F7BC-6584-4440-9763-F0406B33A6AA}\ifc * Database version: 5507 * Database creation date: Thu Oct 11 11:47:02 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Oct 11 11:47:02 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 11 11:47:02 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcUnitaryEquipment: AVK-17HJFCAA, HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVK_INT-EN:AVK-17HJFCAA:1297749
In: V00
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 075-079-084, Color RGB 200-200-200, Color RGB 245-245-245
Type - Dimensions - Depth: 700 mm; Drain Diameter: 18 mm; Height: 630 mm; Refrigerant Gas Diameter: 12.7 mm; Refrigerant Liquid Diameter: 6.35 mm; Width: 225 mm
Type - Electrical - Hertz: 50 Hz; Phase: 1; Voltage: 240 V
Type - Electrical - Loads - Power: 540 W
Type - Identity Data - Article Type: AVK-17HJFCAA; Base Family Version: 11.20; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Air Conditioner; EMCS Version: 4.0; ETIM Article Class: EC011580; Family Version: 11.21; Manufacturer: Hisense; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Model: AVK-17HJFCAA; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Revit Version: 2017; Type Name: AVK-17HJFCAA; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Grey: Color RGB 075-079-084; Light Grey: Color RGB 200-200-200; White: Color RGB 245-245-245
Type - Mechanical - Drain Fixture Units: 0; Drain Flow: 0 m3/s; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s
Type - Mechanical - Loads - Airflow Rate (m3/min): 710; Cooling Capacity (kW): 5; Cooling Power Input (kW): 23; Heating Capacity (kW): 5.6; Heating Power Input (kW): 23; Motor Power: 30; Motor Qty: 1; Unit Weight (kg): 17.4
Type - Other - Category: Mechanical Equipment; Family Name: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVK_INT-EN; Grill Length: 85 mm; Refrigerant Type: R410A
Type - Text - Article Description: Air Conditioner; Manufacturer Art. No.: AVK-17HJFCAA; Product Line: Air Conditioner series
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Angle of the Top Grill: 30 deg; Area: 3.29641 m2; Volume: 0.138433 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Sanitary,Undefined,Power
Mechanical - Loads - Sound Pressure Level (dB(A)): 43
Other - Actual Offset: 10 mm; Angle: 0 deg; Angle of the Top Grill Safe: 30 deg; Family: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVK_INT-EN: AVK-17HJFCAA; Family and Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVK_INT-EN: AVK-17HJFCAA; Front Clearance Safe: 300 mm; Horizontal Offset: 0 mm; Left Clearance Safe: 50 mm; Length to Reference Line: 563.6 mm; Negative Offset: 10 mm; Reference Line Length: 333 mm; Right Clearance Safe: 50 mm; Top Clearance Safe: 300 mm; Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVK_INT-EN: AVK-17HJFCAA; Type Id: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVK_INT-EN: AVK-17HJFCAA; Vertical Offset: 0 mm; Void Depth: 1 mm; Void Height: 1 mm; Void Length: 1 mm
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Concealed Mounting: no; Floor Wall Mounting: yes; Front Clearance: 300 mm; Half Concealed Mounting: no; Left Clearance: 50 mm; Left Connection: yes; Rear Connection Left: yes; Rear Connection Right: no; Right Clearance: 50 mm; Right Connection: no; Show Service Space: no; Top Clearance: 300 mm
